# Keil uVision project ucos_stm32f103.uvprojx, settings and files
target uCOSII-STM32F103RBT6 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos_stm32f103 +hex
  c flags: Optim=1
  c define: STM32F10X_MD  USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CM3;..\App;..\OS-uCOSII\core;..\OS-uCOSII\port;..\Bsp;..\DELAY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\W5500;..\USART;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32F10x_CM3
    ../Libraries/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CM3/startup/: startup_stm32f10x_md.s
  group APP
    ../App/: stm32f10x_it.c stm32f10x_conf.h
    ../APP/: App.c
  group BSP
    ../BSP/: Bsp.c
  group uCOSII_core
    ../OS-uCOSII/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII_port
    ../OS-uCOSII/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ftpClient
    ../USART/: usart.c
    ../DELAY/: delay.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W5500/: W5500.c
    ./: ipCallW5500.c
